# IAR project rfPacketTx.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: CC2650F128 TexasInstruments CC2650F128
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.IExtraOptions: -I$PROJ_DIR$; -DDeviceFamily_CC26X2; -I$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source; -DSUPPORT_PHY_CUSTOM; -DSUPPORT_PHY_2_4_100KBPS2GFSK; -I$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/kernel/nortos; -I$COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/kernel/nortos/posix; --debug; --silent; -e; --aeabi; --thumb; --diag_suppress=Pa050
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: rfPacketTx.hex
  ILINK.IlinkOutputFile: rfPacketTx.out
  ILINK.IlinkIcfFile: rfPacketTx_CC26X2R1_LAUNCHXL_NoRTOS.icf
  ILINK.IlinkExtraOptions: $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/display/lib/display.arm4f; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/grlib/lib/iar/m4f/grlib.a; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/third_party/spiffs/lib/iar/m4f/spiffs_cc26xx.a; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/drivers/rf/lib/rf_multiMode_cc26x2.arm4f; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/drivers/lib/drivers_cc26x2.arm4f; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/kernel/nortos/lib/nortos_cc26x2.arm4f; $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/devices/cc13x2_cc26x2/driverlib/bin/iar/driverlib.lib; --silent; --cpu=Cortex-M4F
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: CC2642R1F TexasInstruments CC2642R1F
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: $PROJ_FNAME$_CC26X2R1_LAUNCHXL_NoRTOS.icf
  group RF Packet TX/Documentation
    $COM_TI_SIMPLELINK_CC13X2_26X2_SDK_INSTALL_DIR$/source/ti/boards/CC26X2R1_LAUNCHXL/: Board.html
    ./: README.md
  group RF Packet TX/Header files
    ./: Board.h CC26X2R1_LAUNCHXL.h
    smartrf_settings/: smartrf_settings.h
  group RF Packet TX/Source files
    ./: CC26X2R1_LAUNCHXL.c CC26X2R1_LAUNCHXL_fxns.c ccfg.c main_nortos.c rfPacketTx.c rfPacketTx_CC26X2R1_LAUNCHXL_NoRTOS.icf
    smartrf_settings/: smartrf_settings.c
